Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2x3 Coordination View
File name: D:\Users\Jonas\Documents\Cadfocus\Ostnor\20140117_CAD-objekt_serie-Rogen\ARBETSMAPP\22261201\AutoCAD Architecture\22261201.ifc
Time: 2014-01-30T15:53:40
Author: - -
Organization: FM Mattsson
Written by: Eurostep IFC Toolbox - 1.0
Made in: AutoCAD Architecture 2009 Build 5.7.68.0

# IfcProject, 22261201
LongName: 22261201
PSET_ACA_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: 02 - Normal detaljering; ACA_DISPLAY_SET_ON_EXPORT: 3D Normal

# IfcBuilding, 22261201
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: 22261201, BUILDINGELEMENTPROXY(1)
In: 22261201
Description: FM Mattsson Rogen Tap valve 15 Hot
